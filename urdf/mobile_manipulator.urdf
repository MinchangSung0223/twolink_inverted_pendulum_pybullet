Commit message: dd

File: urdf/mobile_manipulator.urdf (robot description, URDF)
Before this commit: robot physics, 7 links, 6 joints
Links:
- link link1: mass 1 -> 0
- link link2: mass 1 -> 2
- link link3: mass 1 -> 2
Joints:
- joint eef_joint: type continuous -> fixed
